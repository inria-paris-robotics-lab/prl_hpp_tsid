Commit message: WiP: create gripper and handles

File: prl_hpp/urdf_srdf/support.urdf (robot description, URDF)
Before this commit: robot support, 1 links, 0 joints
Links:
- removed link base_link
- added link support_base; visual box size=0.01 0.025 0.025; visual box size=0.049 0.049 0.049

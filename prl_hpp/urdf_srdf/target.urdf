Commit message: WiP: gripper in targets

File: prl_hpp/urdf_srdf/target.urdf (robot description, URDF)
Before this commit: robot dummy, 1 links, 0 joints
Links:
- removed link dummy_base
- added link target_base; visual box size=0.01 0.025 0.025; visual box size=0.049 0.049 0.049
